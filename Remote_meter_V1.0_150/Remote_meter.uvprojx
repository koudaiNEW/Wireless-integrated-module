# Keil uVision project Remote_meter.uvprojx, settings and files
target main (ARM-ADS)
  device: HC32L170JATA HDSC
  pack: HDSC.HC32L17X.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Remote_meter +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\driver\inc;..\mcu\common;.\src\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group main
    ./src/: main.c
  group module
    ./src/: adc_user.c ble_user.c flash_user.c iic_user.c key_user.c pwm_user.c sys_user.c timer_user.c uart_user.c sensor_user.c ethernet_user.c lcd_user.c
  group driver
    ../driver/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
    ../mcu/common/: interrupts_hc32l17x.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.0
